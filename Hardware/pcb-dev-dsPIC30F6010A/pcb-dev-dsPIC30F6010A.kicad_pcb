# Repository shishir-dey/pcb-dev-dsPIC30F6010A

File README.md:

# pcb-dev-dsPIC30F6010A

<h3>Front View (3D)</h3>

## KiCad design Hardware/pcb-dev-dsPIC30F6010A/pcb-dev-dsPIC30F6010A.kicad_pcb

Board: 4 copper layers, 60.0 x 80.0 mm, 32 parts (0 on the bottom side), 70 nets.

Parts:
C1, C2, C3, C5: 103,1206; CAPC3216X170N
C4, C6, C8, C10, C12: 104,1206; CAPC3216X170N
C7, C13, C15: 1uF, 25V; CP_Radial_D5.0mm_P2.50mm
C9: 0.01uF,1206; CAPC3216X170N
C11: 2.2uF; CP_Radial_D5.0mm_P2.50mm
C14: 2.2uF, 25V; CP_Radial_D5.0mm_P2.50mm
C16, C17: 22pF,1206; CAPC3216X170N
D1: CLL4148; D_1206_3216Metric_Pad1.42x1.75mm_HandSolder
H1, H2, H3, H4: MountingHole_Pad; MountingHole_2.5mm_Pad
J1: Left Berg Strip; PinHeader_2x20_P2.54mm_Vertical
J2: PICkit connector; PinSocket_1x05_P2.54mm_Horizontal
J3: Right Berg Strip; PinHeader_2x20_P2.54mm_Vertical
JP1: Jumper; TestPoint_2Pads_Pitch2.54mm_Drill0.8mm
L1: 0E,1206; L_1206_3216Metric_Pad1.22x1.90mm_HandSolder
R1: 10E,1206; RESC3016X65N
R2: 22K,1206; RESC3016X65N
R3: 470E,1206; RESC3016X65N
U1: DSPIC30F6010A-30I_PF; TQFP-80_14x14mm_P0.65mm
Y1: 10MHz; Crystal_HC18-U_Vertical

Connections:
+5V: C1.1, C2.1, C3.2, C4.2, C5.1, C6.1, C7.1, C8.1, C10.1, C12.1, C13.1, C15.1, D1.1, J2.2, R1.1, R2.2, U1.12, U1.25, U1.32, U1.48, U1.71
GND: C1.2, C2.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.1, H1.1, H2.1, H3.1, H4.1, J1.1, J1.2, J1.3, J1.4, J1.21, J1.22, J1.24, J1.37, J1.38, J1.39, J1.40, J2.3, J3.1, J3.2, J3.37, J3.38, J3.39, J3.40, L1.2, U1.11, U1.31, U1.51, U1.70
MCLR: J2.1, JP1.2, U1.9
unnamed: C14.1, D1.2, R2.1, R3.2
unnamed: C16.1, U1.50, Y1.1
unnamed: C17.2, U1.49, Y1.2
unnamed: JP1.1, R3.1
PGC: J2.5, U1.19
PGD: J2.4, U1.20
RA14: J3.29, U1.52
RA15: J3.28, U1.53
RB2: J1.20, U1.18
RB3: J1.17, U1.17
RB4: J1.18, U1.16
RB5: J1.15, U1.15
RB6: J1.19, U1.21
RB7: J1.23, U1.22
RB12: J1.30, U1.33
RB13: J1.29, U1.34
RB14: J1.32, U1.35
RB15: J1.31, U1.36
RC1: J1.8, U1.4
RC3: J1.9, U1.5
RC13: J3.22, U1.59
RC14: J3.21, U1.60
RD0: J3.23, U1.58
RD1: J3.20, U1.61
RD2: J3.19, U1.62
RD3: J3.18, U1.63
RD4: J3.15, U1.66
RD5: J3.14, U1.67
RD6: J3.13, U1.68
RD7: J3.12, U1.69
RD8: J3.27, U1.54
RD9: J3.26, U1.55
RD10: J3.25, U1.56
RD11: J3.24, U1.57
RD12: J3.17, U1.64
RD13: J3.16, U1.65
RD14: J1.34, U1.37
RD15: J1.33, U1.38
RE0: J3.7, U1.76
RE1: J3.6, U1.77
RE2: J3.5, U1.78
RE3: J3.4, U1.79
RE4: J3.3, U1.80
RE5: J1.5, U1.1
RE6: J1.6, U1.2
RE7: J1.7, U1.3
RE8: J1.14, U1.13
RE9: J1.16, U1.14
RF0: J3.11, U1.72
RF1: J3.10, U1.73
RF2: J3.35, U1.42
RF3: J3.36, U1.41
RF4: J1.36, U1.39
RF5: J1.35, U1.40
RF6: J3.32, U1.45
RF7: J3.33, U1.44
RF8: J3.34, U1.43
RG0: J3.8, U1.75
RG1: J3.9, U1.74
RG2: J3.30, U1.47
RG3: J3.31, U1.46
RG6: J1.10, U1.6
RG7: J1.11, U1.7
RG8: J1.12, U1.8
RG9: J1.13, U1.10
VREF+: C9.1, C11.1, R1.2, U1.24
VSSA: C3.1, C4.1, L1.1, U1.23, U1.26

## Commit log

2021-09-06 Add schematics, annotations and footprints
2021-09-06 Add edge cuts and power planes. Work in progress
2021-09-07 Routed a few decoupling capacitors and pins. Work in progress
2021-09-07 Routed a few decoupling capacitors and pins. Added PCB images. Work in progress
2021-09-07 Add PCB image at this stage"
2021-09-07 Routed a few pins. Work in progress
2021-09-07 Routed a few pins. Add images. Work in progress
2021-09-07 Add schematics in PDF
2021-09-11 Routine done. Add images
2021-09-11 Fix README.md
2021-09-11 Add labels on the PICkit connector
2021-11-24 Add interactive BOM
2021-11-24 Export the interactive BOM to use as home page for GitHub Pages
2021-11-24 Rename GitHub folder to docs as per GitHub's requirement
2024-04-16 Move the link to GitHub Pages from the README to the About section
